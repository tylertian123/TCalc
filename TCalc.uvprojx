# Keil uVision project TCalc.uvprojx, settings and files
target STM32 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TCalc +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c misc: --cpp11 --no_rtti -Ospace --depend_format=unix
  c include: .\src\CMSIS;.\src\Hardware;.\src\Internal;.\src\Lib\inc;.\src\Startup;.\src\User;.\src\8051
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CMSIS
    ./src/CMSIS/: core_cm3.c system_stm32f10x.c
  group Internal
    ./src/Internal/: delay.cpp sys.cpp gpiopin.cpp extipin.cpp sbdi.cpp neda.cpp usart.cpp font.cpp eval.cpp ntoa.cpp snake.cpp util.cpp exprentry.cpp drawbuf.cpp unitconv.cpp
  group Hardware
    ./src/Hardware/: lcd12864_charset.cpp lcdbase.cpp lcd12864.cpp
  group Lib
    ./src/Lib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_flash.c stm32f10x_usart.c stm32f10x_exti.c
  group Startup
    ./src/Startup/: startup_stm32f10x_hd.s
  group User
    ./src/User/: main.cpp
