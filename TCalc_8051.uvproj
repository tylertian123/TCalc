# Keil uVision project TCalc_8051.uvproj, settings and files
target 8051 (MCS-51)
  device: STC12C5616AD STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FF) IROM(0-0x3FFF) CLOCK(45000000)
  output: TCalc_8051 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Main
    ./src/8051/: Main.c SBDI.c ADC.c bmat.c
